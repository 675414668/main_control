# Keil uVision project Project.uvprojx, settings and files
target STM32F401RCT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32E230C_START +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: ..\source\app;..\source\hal;..\source\freertos\inc;..\source\freertos\port\RVDS\ARM_CM3;..\source\osal\inc;..\source\driver\board\STM32F401RCT6\inc;..\source\driver\chip\CMSIS\ST\STM32F4xx\Device\ST\STM32F4xx\Include;..\source\driver\chip\CMSIS\ST\STM32F4xx\Include;..\source\driver\chip\CMSIS\ST\STM32F4xx\Lib\ARM;..\source\app\FATFS\source;..\source\app\MALLOC;..\source\driver\chip\lib\STM32F4xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../source/app/: main.c task_adc.c task_led.c systick.c task_oled.c task_lcd.c
  group hal
    ../source/hal/: hal.c hal_adc.c hal_usart.c hal_timer.c hal_led.c hal_dac.c hal_delay.c hal_oled.c hal_lcd.c hal_lcd_font.c
  group osal
    ../source/osal/src/: osal_task.c osal_time.c osal_sem.c osal_lock.c
  group freertos/src
    ../source/freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/port
    ../source/freertos/port/RVDS/ARM_CM3/: port.c
    ../source/freertos/port/MemMang/: heap_4.c
  group FATFS
    ../source/app/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group MALLOC
    ../source/app/MALLOC/: malloc.c
  group STM32F401/board
    ../source/driver/board/STM32F401RCT6/src/: delay.c led.c
  group stm32f103/board
    ../source/driver/board/STM32F103C8T6/src/: adc.c usart.c timer.c led.c dac.c delay.c oled.c lcd.c spi.c dma.c
  group GD32F130/board
    ../source/driver/board/GD32F130C8T6/src/: delay.c dma.c lcd.c led.c spi.c key.c usart.c timer.c
  group STM32F401/lib
    ../source/driver/chip/lib/STM32F4xx/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c
  group STM32F103/lib
    ../source/driver/chip/lib/STM32F10x/src/: misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group GD32F130/lib
    ../source/driver/chip/lib/GD32F130C8T6/src/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group STM32F401/CMSIS
    ../source/driver/chip/CMSIS/ST/STM32F4xx/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
    ../source/driver/chip/CMSIS/ST/STM32F4xx/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F103/CMSIS
    ../source/driver/chip/CMSIS/ST/STM32F10x/src/: system_stm32f10x.c
    ../source/driver/chip/CMSIS/ST/STM32F10x/src/startup/: startup_stm32f10x_hd.s
    ../source/driver/chip/CMSIS/ST/CM3/: core_cm3.c
  group GD32F130/CMSIS
    ../source/driver/chip/CMSIS/GD/GD32F130/CMSIS/: system_gd32f1x0.c core_cm3.h
    ../source/driver/chip/CMSIS/GD/GD32F130/Startup/: startup_gd32f1x0.s
target GD32F130C8T6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32E230C_START +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,CHIP_GD32F130C8T6
  c include: ..\source\app;..\source\hal;..\source\freertos\inc;..\source\freertos\port\RVDS\ARM_CM3;..\source\osal\inc;..\source\driver\board\GD32F130C8T6\inc;..\source\driver\chip\CMSIS\GD\GD32F130\CMSIS;..\source\driver\chip\CMSIS\GD\GD32F130\Startup;..\source\driver\chip\lib\GD32F130C8T6\inc;..\source\app\FATFS\source;..\source\app\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target STM32F103C8T6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32E230C_START +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,CHIP_STM32F130C8T6
  c include: ..\source\app;..\source\hal;..\source\driver\chip\CMSIS\ST\CM3;..\source\driver\chip\CMSIS\ST\STM32F10x\inc;..\source\driver\board\STM32F103C8T6\inc;..\source\driver\chip\lib\STM32F10x\inc;..\source\freertos\inc;..\source\freertos\port\RVDS\ARM_CM3;..\source\osal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0
